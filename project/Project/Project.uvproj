# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,ARM_MATH_CM3
  c include: ..\Project;..\STM32F2x7_ETH_Driver\inc;..\STM32F2xx_StdPeriph_Driver\inc;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\UCOSII\Port;..\UCOSII\Source;..\User\inc;..\lwip-1.4.1\src\api;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src;..\lwip-1.4.1\src\arch;..\lwip-1.4.1\src\include;..\lwip-1.4.1\src\netif;..\lwip-1.4.1\src\include\posix;..\lwip-1.4.1\src\include\ipv4\lwip;..\lwip-1.4.1\src\include\netif;..\lwip-1.4.1\src\include\lwip
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../User/src/: stm32f2xx_it.c netconf.c i2c_ee.c main.c analyze_data.c compress.c local_conf.c more_infomation.c pack_data.c print_bmp.c print_cells.c print_queue.c printerException.c queue_buf.c status_mesg.c stm32f207_init.c wifi_conf.c RequestHeap.c agent_tcp.c agent_udp.c transfer_task.c
    ../User/inc/: transfer_task.h
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group STARTUP
    ../CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group STM32F2xx_StdPeriph_Driver
    ../STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_usart.c
  group STM32F2x7_ETH_Driver
    ../STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group UCOS_PORT
    ../UCOSII/Port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group UCOS_CORE
    ../UCOSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group LWIP_CORE
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_CORE_IPv4
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_API
    ../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_NETIF
    ../lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group LWIP_ARCH
    ../lwip-1.4.1/src/arch/: sys_arch.c
